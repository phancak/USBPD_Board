File: SMPS_LDO.kicad_sch (KiCad schematic)
At the start: 18 parts, among them U4 MCP16331T-E/CH

Commit message: Change Kicad version
